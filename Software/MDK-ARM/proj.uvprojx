# Keil uVision project proj.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: proj +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DERIVER,ARDUINO=111
  c misc: --gnu
  c include: ..\ArduinoAPI;..\Core;..\Libraries;..\USER;..\Libraries\common;..\Libraries\drivers;..\Libraries\sensors
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.cpp
  group Libraries
    ../Libraries/common/: foc_utils.cpp lowpass_filter.cpp pid.cpp time_utils.cpp
    ../Libraries/communication/: Commander.cpp
    ../Libraries/drivers/: BLDCDriver3PWM.cpp StepperDriver2PWM.cpp StepperDriver4PWM.cpp
    ../Libraries/sensors/: Encoder.cpp MagneticSensorI2C.cpp MagneticSensorSPI.cpp
    ../Libraries/: BLDCMotor.cpp StepperMotor.cpp
    ../Libraries/common/base_classes/: CurrentSense.cpp FOCMotor.cpp Sensor.cpp
  group ArduinoAPI
    ../ArduinoAPI/: Arduino.c dtostrf.c HardwareSerial.cpp itoa.c Print.cpp WString.cpp Wire.cpp WireBase.cpp WMath.cpp SPI.cpp Stream.cpp Tone.cpp
  group Core
    ../Core/: adc.c exti.c gpio.c pwm.c timer.c
    ../CORE/: delay.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
